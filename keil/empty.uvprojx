# Keil uVision project empty.uvprojx, settings and files
target empty (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: empty
  AfterMake: fromelf --bin --output .\Build\empty.bin .\Build\empty.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSP432P401R__
  c include: C:\ti\simplelink_msp432p4_sdk_3_40_01_02\source\;C:\ti\simplelink_msp432p4_sdk_3_40_01_02\source;C:\ti\simplelink_msp432p4_sdk_3_40_01_02\examples\nortos\MSP_EXP432P401R\driverlib;C:\ti\simplelink_msp432p4_sdk_3_40_01_02\source\ti\devices\msp432p4xx\driverlib\keil;..\hardware;..\sys;C:\ti\simplelink_msp432p4_sdk_3_40_01_02;C:\ti\simplelink_msp432p4_sdk_3_40_01_02\source\third_party\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: main.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
  group Library
    C:/ti/simplelink_msp432p4_sdk_3_40_01_02/source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group Hardware
    ../hardware/: led.c key4x4.c
  group sys
    ../sys/: usart.c sysinit.c baudrate_calculate.c delay.c
software components: CMSIS:CORE 5.2.0
